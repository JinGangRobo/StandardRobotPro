# Keil uVision project Keil.uvprojx, settings and files
target Keil (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Keil +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application/assist;../application/chassis;../application/gimbal;../application/other;../application/referee;../application/robot_cmd;../application/shoot;../application/IMU;../application/mechanical_arm;../application/music;../application/custom_controller;../application/communication;../application/calibrate;../application/typedef;../application/typedef_robot;../bsp/boards;../application;../components/devices;../components/algorithm/Include;../components/algorithm;../components/support;../application/protocol;../components/controller
  asm include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group applications/typedef_robot
    ../application/typedef_robot/: robot_param.h robot_param_engineer.h robot_param_engineer_controller.h robot_param_mecannum_hero.h robot_param_omni_infantry.h robot_param_omni_sentry.h robot_param_omni_mini.h robot_param_omni_sentry_two.h robot_param_fly.h
  group applications/typedef
    ../application/typedef/: attribute_typedef.h custom_typedef.h macro_typedef.h robot_typedef.h struct_typedef.h usb_typdef.h
  group applications/robot_cmd
    ../application/robot_cmd/: CAN_receive.c CAN_cmd_dji.c CAN_cmd_cybergear.c motor.c CAN_cmd_damiao.c CAN_cmd_lingkong.c CAN_communication.c SupCap.c CAN_cmd_SupCap.c PWM_cmd_pump.c PWM_cmd_servo.c
  group applications/shoot
    ../application/shoot/: shoot.c shoot_task.c shoot_fric_trigger.c
  group applications/referee
    ../application/referee/: referee.c referee_usart_task.c
  group applications/other
    ../application/other/: led_flow_task.c oled_task.c remote_control.c test_task.c voltage_task.c
  group applications/music
    ../application/music/: music_task.c music.c music_you.c music_unity.c music_canon.c music_castle_in_the_sky.c music_start.c music_referee.c music_error.c music_see_you_again.c music_hao_yun_lai.c music_meow.c music_gong_xi_fa_cai.c music_deja_vu.c
  group applications/mechanical_arm
    ../application/mechanical_arm/: mechanical_arm.c mechanical_arm_task.c mechanical_arm_engineer.c
  group applications/IMU
    ../application/IMU/: IMU_task.c
  group applications/gimbal
    ../application/gimbal/: gimbal.c gimbal_task.c gimbal_yaw_pitch_direct.c gimbal_virtual.c gimbal_double_yaw_pitch.c
  group applications/custom_controller
    ../application/custom_controller/: custom_controller.c custom_controller_task.c custom_controller_engineer.c custom_controller_connect.c
  group applications/communication
    ../application/communication/: communication_task.c communication.c usb_task.c
  group applications/chassis
    ../application/chassis/: chassis.c chassis_power_control.c chassis_task.c chassis_mecanum.c chassis_omni.c
  group applications/calibrate
    ../application/calibrate/: calibrate_task.c
  group applications/assist
    ../application/assist/: detect_task.c data_exchange.c
  group controller
    ../components/controller/: pid.c FF_pid.c npid.c
  group support
    ../components/support/: CRC8_CRC16.c fifo.c mem_mang4.c kalman_filter.c signal_generator.c clist.c matrix.c rls.c
  group algorithm
    ../components/algorithm/: AHRS.lib AHRS_middleware.c arm_cortexM4lf_math.lib user_lib.c
  group devices
    ../components/devices/: OLED.c BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group boards
    ../bsp/boards/: bsp_adc.c bsp_buzzer.c bsp_can.c bsp_crc32.c bsp_delay.c bsp_flash.c bsp_fric.c bsp_imu_pwm.c bsp_i2c.c bsp_laser.c bsp_led.c bsp_rc.c bsp_rng.c bsp_spi.c bsp_usart.c bsp_uart.c bsp_pwm.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0
